<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\printf_uart_debug_tutorial.ewp</path>
  </project>
  <batchBuild />
</workspace>
